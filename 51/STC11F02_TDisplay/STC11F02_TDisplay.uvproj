# Keil uVision project STC11F02_TDisplay.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F02E STC
  cpu: IRAM(0-0xFF) IROM(0-0x7FF) CLOCK(45000000)
  output: STC11F02_TDisplay +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c delay.c ds18b20.c uart.c time0.c display.c
